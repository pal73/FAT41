# Keil uVision project FAT41_1.uvproj, settings and files
target Release (ARM-ADS)
  device: STM32F100R4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: FAT34_1 +hex
  c flags: Optim=4
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Startup
    ./: STM32F10x.s STM32_Init.c
  group Sources
    ./: main.c common_func.c eeprom_map.c at45.c ibatton.c memo.c
  group Lybraries
    ./: 24c01.c i2c.c SPI_STM32F103.c gran.c uart0.c cmd.c
target Simulator (ARM-ADS)
  device: STM32F100R4 STMicroelectronics
  cpu: as above
  output: FAT34_1
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
